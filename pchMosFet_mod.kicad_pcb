# Repository s51517765/Pch_MosFet_module

## KiCad design pchMosFet_mod.kicad_pcb

Parts:
J1: LOAD; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
Q1: 2SC1815; TO-92_Inline
Q2: PMOS; TO-251AB_Horizontal_TabDown
R1, R4: 10k; R_Hybrid_SMD0603_1608_Axial10mm
R2: 2.2k; R_Hybrid_SMD0603_1608_Axial10mm
R3: 120; R_Hybrid_SMD0603_1608_Axial10mm

Connections:
GND: J1.1, J2.1, Q1.1 (E), R4.2
unnamed: J1.2, Q2.1 (D)
unnamed: Q1.3 (B), R1.2, R4.1
unnamed: Q1.2 (C), R3.2
unnamed: Q2.2 (G), R2.2, R3.1
TRIG: J2.2, R1.1
VCC: J2.3, Q2.3 (S), R2.1

Notes on the sheet:
12V程度までならR3は0Ωでも問題ない 24Vぐらいまでなら1～2.2kΩをいれる

Board: 2 copper layers, 14.0 x 44.0 mm, 8 parts (0 on the bottom side), 7 nets.

## Commit log

2026-03-03 VCC/GNDラインの電流容量修正
2026-03-08 Gerberを更新
